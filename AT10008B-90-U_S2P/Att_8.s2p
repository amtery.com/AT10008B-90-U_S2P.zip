#  HZ  S  DB  R  50.00
! Rohde & Schwarz Vector Network Analyzer
! Rohde-Schwarz,ZNB40-4Port,1311601084101679,3.45
! Created: UTC 4/25/2025, 9:30:25 AM
! freq[Hz]  db:S11  ang:S11  db:S21  ang:S21  db:S12  ang:S12  db:S22  ang:S22
! Worked out from all points (weakly coupled two-port):
!   1750 points, 50 MHz to 8 GHz, reference 50 ohm
!   highest |S21| = -12.36 dB at 213.6 MHz (marker M1); lowest = -21.0 dB at 8 GHz (marker M2)
!   lowest |S11| = -38.2 dB at 2.045 GHz (marker M3), VSWR 1.02, Z = 51.2 + j0.361 ohm
!   |S11| at or under -10 dB: 75.5 MHz to end of sweep
!   |S22| runs from -35.7 to -7.3 dB; largest |S21 - S12| = 0.00031
!   S11 on the Smith chart (normalised r, x): 50 MHz: 1.08, -0.99; 163.6 MHz: 0.98, -0.33; 2.268 GHz: 1.04, +0.03; 6.682 GHz: 0.87, +0.25; 8 GHz: 1.33, -0.01
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 50 MHz  -7.3  -14.2  -14.2  -7.3
! 163.6 MHz  -15.7  -12.4  -12.4  -14.9
! 213.6 MHz  -17.8  -12.4  -12.4  -16.5
! 918.2 MHz  -31.0  -13.0  -13.0  -25.5
! 1.377 GHz  -31.6  -13.5  -13.5  -24.0
! 1.673 GHz  -32.6  -13.8  -13.8  -23.5
! 2.045 GHz  -38.2  -14.2  -14.2  -22.6
! 2.268 GHz  -31.9  -14.4  -14.4  -21.5
! 2.7 GHz  -24.5  -14.9  -14.9  -18.4
! 3.323 GHz  -24.6  -15.6  -15.6  -16.6
! 3.895 GHz  -33.0  -16.2  -16.2  -18.5
! 4.027 GHz  -32.9  -16.4  -16.4  -18.1
! 4.359 GHz  -26.9  -16.8  -16.8  -16.5
! 4.668 GHz  -24.3  -17.1  -17.1  -16.0
! 5.35 GHz  -26.9  -17.8  -17.8  -19.7
! 5.664 GHz  -30.8  -18.2  -18.2  -24.2
! 6.014 GHz  -23.2  -18.7  -18.7  -35.7
! 6.327 GHz  -18.6  -19.1  -19.1  -24.9
! 6.677 GHz  -16.5  -19.6  -19.6  -20.2
! 6.682 GHz  -16.5  -19.6  -19.6  -20.2
! 7.259 GHz  -16.5  -20.2  -20.2  -19.4
! 8 GHz  -17.0  -21.0  -21.0  -22.6
