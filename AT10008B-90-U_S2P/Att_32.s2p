#  HZ  S  DB  R  50.00
! Rohde & Schwarz Vector Network Analyzer
! Rohde-Schwarz,ZNB40-4Port,1311601084101679,3.45
! Created: UTC 4/25/2025, 9:31:32 AM
! freq[Hz]  db:S11  ang:S11  db:S21  ang:S21  db:S12  ang:S12  db:S22  ang:S22
! Worked out from all points (weakly coupled two-port):
!   1750 points, 50 MHz to 8 GHz, reference 50 ohm
!   highest |S21| = -36.48 dB at 327.3 MHz (marker M1); lowest = -44.3 dB at 7.995 GHz (marker M2)
!   lowest |S11| = -43.1 dB at 1.2 GHz (marker M3), VSWR 1.01, Z = 49.3 + j0.237 ohm
!   |S11| at or under -10 dB: 55.36 MHz to end of sweep
!   |S22| runs from -27.1 to -9.4 dB; largest |S21 - S12| = 6.7e-05
!   S11 on the Smith chart (normalised r, x): 50 MHz: 0.99, -0.73; 109.1 MHz: 0.99, -0.34; 1.336 GHz: 0.99, +0.01; 8 GHz: 1.31, +0.05
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 50 MHz  -9.2  -37.6  -37.6  -9.4
! 109.1 MHz  -15.5  -36.7  -36.7  -15.1
! 195.5 MHz  -20.6  -36.5  -36.5  -18.8
! 327.3 MHz  -25.2  -36.5  -36.5  -20.9
! 459.1 MHz  -28.3  -36.5  -36.5  -21.9
! 859.1 MHz  -36.0  -36.9  -36.9  -23.8
! 1.109 GHz  -41.9  -37.2  -37.2  -25.1
! 1.2 GHz  -43.1  -37.2  -37.3  -25.6
! 1.336 GHz  -41.6  -37.4  -37.4  -26.3
! 1.377 GHz  -40.6  -37.4  -37.4  -26.5
! 1.668 GHz  -34.9  -37.7  -37.7  -27.1
! 1.968 GHz  -31.2  -38.1  -38.1  -26.0
! 2.336 GHz  -28.5  -38.4  -38.4  -24.1
! 2.7 GHz  -27.2  -39.0  -39.0  -22.7
! 3.391 GHz  -25.1  -39.7  -39.7  -20.2
! 4.027 GHz  -25.5  -40.3  -40.3  -19.6
! 5.35 GHz  -26.4  -41.9  -41.9  -18.4
! 5.814 GHz  -24.9  -42.4  -42.4  -18.5
! 6.677 GHz  -19.9  -43.1  -43.1  -19.3
! 7.336 GHz  -17.9  -43.7  -43.7  -21.2
! 7.995 GHz  -17.3  -44.3  -44.3  -24.4
! 8 GHz  -17.3  -44.2  -44.3  -24.5
