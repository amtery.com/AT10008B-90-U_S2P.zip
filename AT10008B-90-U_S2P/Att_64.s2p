#  HZ  S  DB  R  50.00
! Rohde & Schwarz Vector Network Analyzer
! Rohde-Schwarz,ZNB40-4Port,1311601084101679,3.45
! Created: UTC 4/25/2025, 9:32:58 AM
! freq[Hz]  db:S11  ang:S11  db:S21  ang:S21  db:S12  ang:S12  db:S22  ang:S22
! Worked out from all points (weakly coupled two-port):
!   1750 points, 50 MHz to 8 GHz, reference 50 ohm
!   highest |S21| = -68.02 dB at 454.5 MHz (marker M1); lowest = -75.7 dB at 7.941 GHz (marker M2)
!   lowest |S11| = -33.1 dB at 1.555 GHz (marker M3), VSWR 1.05, Z = 48 + j0.856 ohm
!   |S11| at or under -10 dB: 52.44 MHz to end of sweep
!   |S22| runs from -45.4 to -9.4 dB; largest |S21 - S12| = 1.7e-05
!   S11 on the Smith chart (normalised r, x): 50 MHz: 1.04, -0.71; 5.677 GHz: 0.84, +0.04; 7.023 GHz: 1.09, +0.30; 8 GHz: 1.29, -0.14
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 50 MHz  -9.6  -69.4  -69.5  -9.4
! 127.3 MHz  -17.0  -68.9  -68.9  -17.2
! 204.5 MHz  -20.5  -68.6  -68.7  -21.6
! 313.6 MHz  -23.2  -68.2  -68.3  -25.7
! 454.5 MHz  -24.9  -68.0  -68.1  -29.5
! 754.5 MHz  -27.1  -68.4  -68.4  -36.6
! 1.036 GHz  -29.3  -68.9  -68.9  -45.3
! 1.114 GHz  -30.0  -69.0  -68.9  -44.5
! 1.377 GHz  -32.3  -69.3  -69.3  -37.1
! 1.555 GHz  -33.1  -69.6  -69.6  -33.6
! 1.745 GHz  -32.6  -69.8  -69.8  -31.1
! 2.155 GHz  -29.5  -70.3  -70.3  -27.6
! 2.7 GHz  -27.1  -71.2  -71.2  -25.5
! 3.323 GHz  -24.5  -71.9  -71.9  -23.3
! 4.027 GHz  -24.5  -72.6  -72.8  -23.3
! 4.75 GHz  -24.3  -73.4  -73.5  -24.5
! 5.35 GHz  -22.3  -74.3  -74.5  -23.9
! 5.677 GHz  -20.8  -74.8  -74.5  -22.9
! 6.677 GHz  -17.2  -75.3  -75.2  -19.8
! 7.023 GHz  -16.7  -75.3  -75.2  -19.2
! 7.941 GHz  -16.9  -75.7  -75.5  -19.2
! 8 GHz  -17.0  -75.6  -75.6  -19.2
