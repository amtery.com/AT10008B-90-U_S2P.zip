#  HZ  S  DB  R  50.00
! Rohde & Schwarz Vector Network Analyzer
! Rohde-Schwarz,ZNB40-4Port,1311601084101679,3.45
! Created: UTC 4/25/2025, 9:30:55 AM
! freq[Hz]  db:S11  ang:S11  db:S21  ang:S21  db:S12  ang:S12  db:S22  ang:S22
! Worked out from all points (weakly coupled two-port):
!   1750 points, 50 MHz to 8 GHz, reference 50 ohm
!   highest |S21| = -20.45 dB at 190.9 MHz (marker M1); lowest = -28.9 dB at 8 GHz (marker M2)
!   lowest |S11| = -23.1 dB at 1.695 GHz (marker M3), VSWR 1.15, Z = 44.3 + j3.41 ohm
!   |S11| at or under -10 dB: 62.1 MHz to end of sweep
!   |S22| runs from -38.6 to -8.5 dB; largest |S21 - S12| = 0.00014
!   S11 on the Smith chart (normalised r, x): 50 MHz: 1.21, -0.85; 1.918 GHz: 0.93, +0.12; 8 GHz: 1.16, +0.01
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 50 MHz  -8.6  -21.9  -21.9  -8.5
! 122.7 MHz  -14.0  -20.6  -20.6  -15.5
! 190.9 MHz  -16.0  -20.5  -20.5  -19.2
! 295.5 MHz  -17.5  -20.5  -20.5  -23.0
! 440.9 MHz  -18.7  -20.7  -20.7  -26.8
! 959.1 MHz  -21.6  -21.2  -21.2  -37.6
! 1.127 GHz  -22.2  -21.4  -21.4  -38.3
! 1.377 GHz  -22.8  -21.6  -21.6  -35.0
! 1.695 GHz  -23.1  -21.9  -21.9  -30.3
! 1.918 GHz  -22.9  -22.2  -22.1  -28.1
! 2.286 GHz  -21.9  -22.5  -22.5  -24.8
! 2.7 GHz  -20.5  -23.1  -23.1  -22.6
! 3.314 GHz  -19.7  -23.8  -23.8  -21.5
! 4.027 GHz  -20.7  -24.5  -24.5  -22.8
! 4.818 GHz  -19.3  -25.3  -25.3  -22.8
! 5.35 GHz  -20.0  -25.9  -25.9  -26.3
! 5.668 GHz  -21.0  -26.3  -26.3  -30.5
! 5.809 GHz  -21.5  -26.4  -26.4  -31.0
! 6.314 GHz  -21.9  -27.0  -27.0  -23.7
! 6.677 GHz  -21.2  -27.4  -27.4  -20.8
! 7.168 GHz  -21.1  -28.0  -28.0  -20.0
! 8 GHz  -22.6  -28.9  -28.9  -21.8
